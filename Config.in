## Kconfig
```kconfig
config KRealtek
	tristate "realtek support"
	help
	  This adds support for the realtek.
```
